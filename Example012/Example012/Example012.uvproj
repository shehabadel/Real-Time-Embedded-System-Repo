# Keil uVision project Example012.uvproj, settings and files
target Source (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Example012
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Example012;..\..\FreeRTOS-Source\include;..\..\FreeRTOS-Source\portable\RVDS\ARM_CM3;..\..\FreeRTOS-Source\demo_code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group FreeRTOS_source
    ../../FreeRTOS-Source/: list.c queue.c tasks.c
    ../../FreeRTOS-Source/portable/MemMang/: heap_1.c
    ../../FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
  group Demo_source
    ./: main.c
    ../../FreeRTOS-Source/demo_code/: basic_io.c
  group System_source
    ./: startup_MPS_CM3.s
