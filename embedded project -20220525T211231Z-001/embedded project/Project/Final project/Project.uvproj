# Keil uVision project Project.uvproj, settings and files
target IO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: IO.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: .;..;..\..\..;..\Source;..\Source\include;..\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c startup_rvmdk.S LCD.c LCD.h Uart.c Uart.h
    ../Source/: croutine.c list.c queue.c tasks.c timers.c
    ../Source/portable/RVDS/ARM_CM4F/: port.c
    ../Source/portable/MemMang/: heap_2.c
